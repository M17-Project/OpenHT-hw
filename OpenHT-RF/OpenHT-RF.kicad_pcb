# Repository M17-Project/OpenHT-hw

File README.md:

# OpenHT-hw
Hardware part of the OpenHT - an open-source, SDR handheld transceiver.

## Description
The device is a complete, low RF power I/Q transceiver, supporting virtually any mode (including [M17](https://m17project.org) and [FreeDV](https://freedv.org)).
It is built around the [AT86RF215 chip](https://www.microchip.com/en-us/product/AT86RF215) by Microchip/Atmel
and [LIFCL-40-9SG72C](https://www.latticesemi.com/Products/FPGAandCPLD/CrossLink-NX) FPGA from Lattice as a shield for [32F469IDISCOVERY](https://www.st.com/en/evaluation-tools/32f469idiscovery.html). It is possible to use the board with other MCU platforms.

Technical details:
- frequency range: 389.5 - 480, 2400 - 2483.5 MHz (RX, TX frequency range is limited by your local laws)
- RF power output: <14dBm (<25mW)

## Assembly tips and U204 issue
After the board has been populated, perform the steps below:
1) Remove JP201 (undervoltage lock-out).
2) Remove U204 (you need to take the lower shield off).
3) Using a copper wire, connect `VIN` and `VBAT`.
4) Secure goldpin headers in place by putting them on the DISCO board (Arduino male connector and the 2x8 female connector) and solder them.
5) Populate JP401 and short the two left pins,`JTAG_EN` to `GND`, "OFF" position.
6) Prepare a micro-SD card with the FPGA image, its filename should be `OpenHT_impl_1.bit`. The SD card has to be preformatted with FAT32.
7) Plug the mini-USB port and flash the firmware from the `main` branch.
8) In the GUI, tap on the cog icon (upper left corner), then press the `Erase NOR` button. After a few seconds (about 3), press the `SD to NOR` button and wait a few seconds more.
9) After the flashing is done, press and hold the power-on button for at least 1.5 seconds. The "LED" next to the cog icon should light up in green.

Step 8) needs to be performed only *once* for a fresh FPGA image. After that, the image is transferred to the NOR flash and is supposed to be retrieved by the FPGA automagically.
It is highly recommended to use terminal for getting debug info. The terminal is 115,200 baud, 8n1, over the COM port exposed by the DISCO board.

## KiCad design OpenHT-RF/OpenHT-RF.kicad_pcb

Parts:
C69: 1uF; C_0402_1005Metric; MPN Generic C/1uF/0402/X5R/10V
FID101, FID102, FID103: Fiducial; Fiducial_1mm_Mask2mm
LOGO101: M17_logo_20mmx15mm; M17_logo_12x7.5mm
LS101: SP-1605; Pin_1x02_P2.54mm_horizontal_SMD; MPN SP-1605
R11: 1kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/1kR/0402/1%
SW2: 436351045816; SW_SPST_436351045816; MPN 436351045816
SYM101: Logo_Open_Hardware_Small; OSHW-Logo_7.5x8mm_SilkScreen

Connections:
/Connectors/SPK_N: LS101.2; also elsewhere on the board
/Connectors/SPK_P: LS101.1; also elsewhere on the board

Parts:
C201, C205, C220, C225: 1uF; C_0402_1005Metric; MPN Generic C/1uF/0402/X5R/10V
C202: 18nF; C_0402_1005Metric; MPN Generic C/18nF/0402/X7R/10V
C203, C204: 0.15uF; C_0402_1005Metric; MPN Generic C/0.15uF/0402/X5R/10V
C206, C208, C209, C210, C211, C218, C219, C221, C222, C223: 4.7uF; C_0805_2012Metric; Rated voltage 50V or higher; MPN Generic C/4.7uF/0805/X5R/25V
C207, C224: 4.7uF; C_0805_2012Metric; Rated voltage 50V or higher; MPN Generic C/4.7uF/0805/X5R/25V; not fitted
C212: 3.9pF; C_0402_1005Metric; MPN Generic C/3.9pF/0402/C0G/10V
C213: 4.5pF; C_0402_1005Metric; MPN Generic C/4.5pF/0402/C0G/10V
C214, C215: 47nF; C_0402_1005Metric; Voltage 10V or higher; MPN Generic C/47nF/0402/X5R/10V
C216: 1.2nF; C_0402_1005Metric; MPN Generic C/1.2nF/0402/X7R/10V
C217: 1nF; C_0402_1005Metric; MPN Generic C/1nF/0402/X7R/10V
C226: 6.8nF; C_0402_1005Metric; MPN Generic C/6.8nF/0402/X5R/10V
C227: 0.1uF; C_0402_1005Metric; MPN Generic C/0.1uF/0402/X7R/16V
C228, C229: 470pF; C_0402_1005Metric; MPN Generic C/470pF/0402/X7R/16V
F201: Polyfuse; Fuse_1812_4532Metric; MPN SMD1812B200TF/16
J201: Conn_01x02; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal
J202: MS338-10F; MPN MS338-10F
J203: MS338-10C; MPN MS338-10C
JP201, JP202, JP203, JP204: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Right; MPN 10129380-902001BLF or equivalent
L201: 33uH; L_Taiyo-Yuden_NR-5030; MPN LSXND5050XKT330MMG
L202: 47uH; L_Wurth_WE-LQSF-4828; MPN 74406043470
Q201: DMP3099L-7; SOT-23; MPN DMP3099L-7
R201: 200kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/200kR/0402/1%
R202: 1kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/1kR/0402/1%
R203: 47.5kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/47.5kR/0402/1%
R204: 110kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/110kR/0402/1%
R205, R206: 100kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100kR/0402/1%
R207: 1.6kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/1.6kR/0402/1%
R208: 3.16kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/3.16kR/0402/1%
R209: 43kR; R_0402_1005Metric; Tolerance 0.1% or better; MPN Generic R/43kR/0402/0.1%
R210: 9.53kR; R_0402_1005Metric; Tolerance 0.1% or better; MPN Generic R/9.53kR/0402/0.1%
R211: 20kR; R_0402_1005Metric; Tolerance 0.1% or better; MPN Generic R/20kR/0402/0.1%
R212: 10kR; R_0402_1005Metric; Tolerance 0.1% or better; MPN Generic R/10kR/0402/0.1%
R213: 2.55kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/2.55kR/0402/1%
R214: 10.2kR; R_0402_1005Metric; Tolerance 0.1%; MPN Generic R/10.2kR/0402/0.1%
R301: 100R; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100R/0402/1%
SW201: 436351045816; SW_SPST_436351045816; MPN 436351045816
TP201, TP202, TP203, TP204, TP205, TP206, TP207, TP208, TP209, TP210: TestPoint; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
U201: LTC2954-1; TSOT-23-8; MPN LTC2954CTS8-1#TRMPBF
U202: TPS65261RHBx; VQFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm_ThermalVias; MPN TPS65261RHBR
U203: AP7330-W5-7; SOT-23-5; MPN AP7330-W5-7
U204: TPS22810DBVR; SOT-23-6; MPN TPS22810DBVR

Connections:
+1V0: JP204.2 (B); also elsewhere on the board
+1V8: C220.1, JP203.2 (B), TP203.1, U203.1 (V_{in}), U203.3 (EN); also elsewhere on the board
+3V3: JP202.2 (B), R205.1, R206.1, TP202.1; also elsewhere on the board
+BATT: C201.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C227.1, Q201.2 (S), R201.1, R202.1, TP201.1, U202.12 (PVIN2), U202.28 (PVIN1), U202.29 (VIN), U204.1 (VIN); also elsewhere on the board
/Connectors/MAIN_KILL: U201.8 (~KILL); also elsewhere on the board
/Connectors/MCU_NRST: R206.2, U202.3 (RESET); also elsewhere on the board
/Connectors/PB_INT: U201.5 (~INT); also elsewhere on the board
/Power supply/PWR_EN: TP205.1, U201.6 (EN), U202.31 (EN1), U202.32 (EN2), U204.3 (EN/UVLO)
/Power supply/SS_CAP: C202.1, U202.8 (SS2), U202.24 (SS1)
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, J201.2, J202.1 (Shield), JP201.1 (A), Q201.1 (G), R204.2, R210.2, R212.2, R214.2, SW201.2, TP204.1, TP206.1, TP207.1, TP208.1, TP209.1, TP210.1, U201.4 (GND), U202.1 (EN3), U202.4 (MODE), U202.11 (PGND2), U202.13 (PVIN3), U202.14 (PGND3), U202.21 (AGND), U202.27 (PGND1), U202.33 (PAD), U203.2 (GND), U204.2 (GND); also elsewhere on the board
unnamed: C216.1, R207.2
unnamed: C217.1, R208.2
unnamed: F201.1, J201.1
unnamed: JP201.2 (B), R203.1
unnamed: C218.1, C221.1, C223.1, C228.1, JP202.1 (A), L201.2, R209.1
unnamed: C219.1, C222.1, C224.1, C229.1, JP203.1 (A), L202.2, R211.1
unnamed: C225.1, JP204.1 (A), R213.1, U203.5 (V_{out})
unnamed: F201.2, Q201.3 (D)
unnamed: C203.1, U201.3 (ONT)
unnamed: C204.1, U201.7 (PDT)
unnamed: R202.2, U201.1 (V_{in})
unnamed: SW201.1, U201.2 (~PB)
unnamed: R204.1, U202.20 (ROSC)
unnamed: C205.1, U202.5 (V7V)
unnamed: R201.2, R203.2, U202.30 (VDIV)
unnamed: C214.1, U202.25 (BST1)
unnamed: C212.1, R207.1, U202.23 (COMP1)
unnamed: C228.2, R209.2, R210.1, U202.22 (FB1)
unnamed: C214.2, L201.1, U202.26 (LX1)
unnamed: C215.1, U202.9 (BST2)
unnamed: C213.1, R208.1, U202.7 (COMP2)
unnamed: C229.2, R211.2, R212.1, U202.6 (FB2)
unnamed: C215.2, L202.1, U202.10 (LX2)
unnamed: R213.2, R214.1, U203.4 (ADJ)
unnamed: C226.1, U204.4 (CT)

Notes on the sheet:
For the calculations and details on dimensioning, see ./power_supply.md
Open this jumper to disable UVLO

Parts:
C301: 0.1uF; C_0402_1005Metric; MPN Generic C/0.1uF/0402/X7R/16V
D301: BAT60A; D_SOD-323; MPN BAT60AE6327HTSA1
H301, H302, H303, H304: M3; MountingHole_3.2mm_M3_DIN965
J5, J8: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J6: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J7: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J303: Conn_02x08_Odd_Even; PinSocket_2x08_P2.54mm_Vertical
JP301: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R301, R302, R303, R304, R305, R306, R307, R308, R309, R310, R311, R313, R314, R315, R316: 100R; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100R/0402/1%
R312: 200kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/200kR/0402/1%
R317: 100kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100kR/0402/1%
TP301, TP302, TP303, TP304, TP305, TP306, TP307, TP308: TestPoint; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork

Connections:
+BATT: D301.1 (K); also elsewhere on the board
/Connectors/DONE: R305.2; also elsewhere on the board
/Connectors/FPGA_RST: TP308.1; also elsewhere on the board
/Connectors/INITN: R311.2; also elsewhere on the board
/Connectors/IO0: TP301.1; also elsewhere on the board
/Connectors/IO1: TP302.1; also elsewhere on the board
/Connectors/IO2: TP303.1; also elsewhere on the board
/Connectors/IO3: TP304.1; also elsewhere on the board
/Connectors/IO4: R307.2, TP305.1; also elsewhere on the board
/Connectors/IO5: R306.2, TP306.1; also elsewhere on the board
/Connectors/IO6: R308.2, TP307.1; also elsewhere on the board
/Connectors/IRQ_AT86RF215: R315.2; also elsewhere on the board
/Connectors/MAIN_KILL: R314.2; also elsewhere on the board
/Connectors/MCU_NRST: JP301.1 (A); also elsewhere on the board
/Connectors/PB_INT: R313.2; also elsewhere on the board
/Connectors/PROGRAMN: R310.2; also elsewhere on the board
/Connectors/RF_RST: R316.2; also elsewhere on the board
/Connectors/SPI_NSS2: R304.1; also elsewhere on the board
/Connectors/SPK_N: J303.15; also elsewhere on the board
/Connectors/SPK_P: J303.16; also elsewhere on the board
/Connectors/SW_CTL1: J303.8; also elsewhere on the board
/Connectors/SW_CTL2: J303.10; also elsewhere on the board
/FPGA/TCK/SCLK: R302.1; also elsewhere on the board
/FPGA/TDI/SSI: R303.1; also elsewhere on the board
/FPGA/TDO/SSO: J303.5; also elsewhere on the board
/FPGA/TMS/SCSN: R309.2; also elsewhere on the board
GND: C301.2, J303.2, R317.2; also elsewhere on the board
unnamed 55: D301.2 (A); also elsewhere on the board
unnamed 62: R305.1; also elsewhere on the board
unnamed 63: R310.1; also elsewhere on the board
unnamed 64: R311.1; also elsewhere on the board
unnamed 65: C301.1, R312.2, R317.1; also elsewhere on the board
unnamed 66: JP301.2 (B); also elsewhere on the board
unnamed: J303.7, R302.2
unnamed: J303.9, R303.2
unnamed: J303.11, R304.2
unnamed: J303.12, R316.1
unnamed 71: R308.1; also elsewhere on the board
unnamed 72: R306.1; also elsewhere on the board
unnamed 73: R307.1; also elsewhere on the board
unnamed 74: R309.1; also elsewhere on the board
unnamed 75: R313.1; also elsewhere on the board
unnamed 76: R314.1; also elsewhere on the board
unnamed 77: R315.1; also elsewhere on the board

Notes on the sheet:
SPI1_MISO (PB4)
(PG12)
NRST
I2C1_SDA (PB9)
TIM12_CH1 (PH6)
A0 (PB1)
+5V
AVdd
I2C2_WS, TIM1_BKIN (PB12)
TIM3_CH1 (PA6)
I2C1_SCL(PB8)
TIM5_CH2 (PA1)
A4 (PC5)
USART6_TX (PG14)
USART6_RX, TIM3/TIM8_CH2 (PC7)
MCO1, TIM1_CH1 (MCO1)
SPI1_MOSI (PB5)
GND
SPI2_MISO (PB14)
SPI1_NSS (PA15)
USART6_RX (PG9)
(PG11)
(PG10)
IOREF
2x8 CN12 connector
USART6_TX, TIM3/TIM8_CH1 (PC6)
TIM12_CH2, SPI2_MOSI (PB15)
SPI1_SCK (PA5)
A1 (PC2)
A5 (PA4)
TIM14_CH1 (PA7)
ADC1/ADC2/ADC3_IN11 (PC1)
+3V3
SPI2_SCK (PD3)
Vin
A3 (PC4)
ANTITAMP1 (PC13)
Arduino uno connector
A2 (PC3)
TIM5_CH3 (PA2)

Parts:
C401, C402, C403, C404, C405, C416, C419, C425: 10uF; C_0805_2012Metric; MPN Generic C/10uF/0805/X5R/10V
C406, C407, C408, C409, C410, C411, C412, C413, C414, C415, C417, C418, C420, C421, C422, C427, C428: 0.1uF; C_0402_1005Metric; MPN Generic C/0.1uF/0402/X7R/16V
C423: 10uF; C_0805_2012Metric; MPN Generic C/10uF/0805/X5R/10V; not fitted
C424: 0.1uF; C_0402_1005Metric; MPN Generic C/0.1uF/0402/X7R/16V; not fitted
C426: 1uF; C_0402_1005Metric; MPN Generic C/1uF/0402/X5R/10V
FB401, FB402, FB403: BLM15AG121SN1D; L_0402_1005Metric; MPN BLM15AG121SN1D
FB404: BLM15AG121SN1D; L_0402_1005Metric; MPN BLM15AG121SN1D; not fitted
J401: Conn_01x06; PinSocket_1x06_P2.54mm_Horizontal; not fitted
J402: MS300-10F; MPN MS300-10F
J403: MS300-10C; MPN MS300-10C
JP401: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
R401: 10kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/10kR/0402/1%
R402: 100R; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100R/0402/1%
TP401, TP402: TestPoint; Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
U401: LIFCL-40-9SG72C; QFN-72-1EP_10x10mm_P0.5mm_EP6.2x6.2mm_ThermalVias; MPN LIFCL-40-9SG72C

Connections:
+1V0: FB401.1; also elsewhere on the board
+1V8: FB403.1, FB404.1; also elsewhere on the board
+3V3: FB402.1, J401.5, R401.1; also elsewhere on the board
/Connectors/DONE: U401.58 (PT76B/DONE); also elsewhere on the board
/Connectors/FPGA_RST: U401.53 (PT82B/MCSNO); also elsewhere on the board
/Connectors/INITN: U401.61 (PT74A/INITN); also elsewhere on the board
/Connectors/IO0: U401.44 (PR11B/SCL); also elsewhere on the board
/Connectors/IO1: U401.42 (PR11A/SDA); also elsewhere on the board
/Connectors/IO2: U401.51 (PT80A/MISO); also elsewhere on the board
/Connectors/IO3: U401.52 (PT82A); also elsewhere on the board
/Connectors/IO4: U401.55 (PT80B); also elsewhere on the board
/Connectors/IO5: U401.56 (PT78A/MCSN); also elsewhere on the board
/Connectors/IO6: U401.57 (PT78B/MOSI); also elsewhere on the board
/Connectors/PROGRAMN: U401.60 (PT74B/PROGRAMN); also elsewhere on the board
/FPGA/CLK_IN: U401.59 (PT76A/MCLK); also elsewhere on the board
/FPGA/LVDS_RX09_N: U401.28 (PB68B); also elsewhere on the board
/FPGA/LVDS_RX09_P: U401.27 (PB68A); also elsewhere on the board
/FPGA/LVDS_RX24_N: U401.23 (PB54B); also elsewhere on the board
/FPGA/LVDS_RX24_P: U401.22 (PB54A); also elsewhere on the board
/FPGA/LVDS_RXCLK_N: U401.25 (PB58B); also elsewhere on the board
/FPGA/LVDS_RXCLK_P: U401.24 (PB58A); also elsewhere on the board
/FPGA/LVDS_TXCLK_N: U401.34 (PB74B); also elsewhere on the board
/FPGA/LVDS_TXCLK_P: U401.33 (PB74A); also elsewhere on the board
/FPGA/LVDS_TX_N: U401.31 (PB72B); also elsewhere on the board
/FPGA/LVDS_TX_P: U401.30 (PB72A); also elsewhere on the board
/FPGA/TCK/SCLK: J401.1, U401.41 (P13A/TCK/SCLK); also elsewhere on the board
/FPGA/TDI/SSI: J401.3, U401.46 (PR8B/TDI/SSI); also elsewhere on the board
/FPGA/TDO/SSO: J401.4, R402.2; also elsewhere on the board
/FPGA/TMS/SCSN: J401.2, U401.48 (PR6B/TMS/SCSN); also elsewhere on the board
/FPGA/VCC: C401.1, C402.1, C404.1, C406.1, C408.1, C410.1, C412.1, C414.1, C415.1, C417.1, C420.1, FB401.2, TP402.1, U401.5 (VCCPLL_ULC), U401.6 (VCC), U401.12 (VCC), U401.21 (VCC), U401.35 (VCC), U401.38 (VCC), U401.40 (VCC), U401.62 (VCC)
/FPGA/VCCAUX: C403.1, C405.1, C407.1, C409.1, C411.1, C413.1, C416.1, C418.1, C421.1, C426.1, C428.1, FB403.2, U401.7 (VCCAUX), U401.17 (VCCAUXH5), U401.18 (VCCIO5), U401.26 (VCCIO3), U401.29 (VCCAUXH3), U401.32 (VCCIO3), U401.47 (VCCAUX)
/FPGA/VCCIO_3V3: C419.1, C422.1, C425.1, C427.1, FB402.2, U401.49 (VCCIO1), U401.54 (VCCIO0)
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C428.2, J401.6, J402.1 (Shield), JP401.1 (A), U401.73 (GND); also elsewhere on the board
unnamed: JP401.3 (B), R401.2
unnamed: JP401.2 (C), U401.50 (JTAG_EN)
unnamed: TP401.1, U401.43 (PR13B)
unnamed: C423.1, C424.1, FB404.2, U401.39 (VCCADC18)

Notes on the sheet:
If needed, IO4, IO5, IO6 can be used as SPI bus (SPI2 on the MCU)
If pulled high, the SPI pins will be reconfigured as JTAG pins
Configuration port: Slave SPI LIFCL-40: Slave MOSI (SSI) : PR8B Slave MISO (SSO) : PR10B Slave clock (SCLK) : PR13A Slave CS (SCSN) : PR6B ProgramN : PT74B LIFCL-17: Slave MOSI (SSI) : PR5A Slave MISO (SSO) : PR5B Slave clock (SCLK) : PR9A Slave CS (SCSN) : PR3B ProgramN : PT57B The physical pin st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
Leave VCCADC18 open if not used.

Parts:
C501, C517, C518, C519, C520, C521: 0.1uF; C_0402_1005Metric; MPN Generic C/0.1uF/0402/X7R/16V
C502, C503: 1.8pF; C_0402_1005Metric; MPN Generic C/1.8pF/0402/C0G/10V
C504: 1nF; C_0402_1005Metric; MPN Generic C/1nF/0402/X7R/10V
C505: 1nF; C_0402_1005Metric; MPN Generic C/1nF/0402/C0G/10V
C506: 10pF; C_0402_1005Metric; MPN Generic C/10pF/0402/C0G/10V
C508, C514, C515: 1uF; C_0402_1005Metric; MPN Generic C/1uF/0402/X5R/10V
C509, C510, C513: 100pF; C_0402_1005Metric; MPN Generic C/100pF/0402/C0G/10V
C511: 220pF; C_0402_1005Metric; MPN Generic C/220pF/0402/C0G/10V
C512: 82pF; C_0402_1005Metric; MPN Generic C/82pF/0402/C0G/10V
C516: 2.2pF; C_0402_1005Metric; MPN Generic C/2.2pF/0402/C0G/10V
C522: 10uF; C_0805_2012Metric; MPN Generic C/10uF/0805/X5R/10V
C523: 1nF; C_0402_1005Metric; MPN Generic C/1nF/0402/X7R/10V; not fitted
D501: D_TVS; D_Toshiba_CST2; MPN DF2B5M4CT,L3F
FB501: BLM15AG121SN1D; L_0402_1005Metric; MPN BLM15AG121SN1D
FL501: LFCN-490+; Filter_Mini-Circuits_FV1206; MPN LFCN-490+
FL502: LFCN-2500+; Filter_Mini-Circuits_FV1206; MPN LFCN-2500+
J501: EMPCB.CSMAFSTJ.A; SMA_Taoglas_EMPCB.CSMAFSTJ.A; MPN EMPCB.CSMAFSTJ.A
J502, J503: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; not fitted
J504: MS300-10F; MPN MS300-10F
J505: MS300-10C; MPN MS300-10C
L501: 5.6nH; L_0402_1005Metric; MPN LRC0402CS5N6GV001T
L502: 2450FB15A050; MPN 2450FB15A0050001E
L503: ATB2012-50011; ATB2012; MPN ATB2012-50011-T000
R3: 100kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100kR/0402/1%
R402: 100R; R_0402_1005Metric; Tolerance 1%; MPN Generic R/100R/0402/1%
R501: 10kR; R_0402_1005Metric; Tolerance 1%; MPN Generic R/10kR/0402/1%
R503: 220R; R_0402_1005Metric; Tolerance 1%; MPN Generic R/220R/0402/1%
SW501: RFSW8008; MPN RFSW8008TR7
U501: AT86RF215; VQFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm_ThermalVias; MPN AT86RF215-ZU
X501: ECS-TXO-20CSMV; MPN ECS-TXO-20CSMV-260-AY-TR

Connections:
+3V3: C501.1, C523.1, FB501.1, SW501.3 (VDD), X501.4 (VCC); also elsewhere on the board
/Connectors/IRQ_AT86RF215: U501.40 (IRQ); also elsewhere on the board
/Connectors/RF_RST: U501.13 (~RSTN); also elsewhere on the board
/Connectors/SPI_NSS2: U501.42 (~SELN); also elsewhere on the board
/Connectors/SW_CTL1: C511.1, SW501.7 (CTL1); also elsewhere on the board
/Connectors/SW_CTL2: C512.1, SW501.1 (CTL2); also elsewhere on the board
/FPGA/CLK_IN: C516.1, R503.1; also elsewhere on the board
/FPGA/LVDS_RX09_N: U501.30 (RXDN09); also elsewhere on the board
/FPGA/LVDS_RX09_P: U501.31 (RXDP09); also elsewhere on the board
/FPGA/LVDS_RX24_N: U501.35 (RXDN24); also elsewhere on the board
/FPGA/LVDS_RX24_P: U501.36 (RXDP24); also elsewhere on the board
/FPGA/LVDS_RXCLK_N: U501.33 (RXCLKN); also elsewhere on the board
/FPGA/LVDS_RXCLK_P: U501.34 (RXCLKP); also elsewhere on the board
/FPGA/LVDS_TXCLK_N: U501.25 (TXCLKN); also elsewhere on the board
/FPGA/LVDS_TXCLK_P: U501.26 (TXCLKP); also elsewhere on the board
/FPGA/LVDS_TX_N: U501.27 (TXDN); also elsewhere on the board
/FPGA/LVDS_TX_P: U501.28 (TXDP); also elsewhere on the board
/FPGA/TCK/SCLK: U501.41 (SCLK); also elsewhere on the board
/FPGA/TDI/SSI: U501.43 (MOSI); also elsewhere on the board
/FPGA/TDO/SSO: R402.2; also elsewhere on the board
/RF/DEVDD: C517.1, C518.1, C519.1, C520.1, C521.1, C522.1, FB501.2, U501.15 (EVDD), U501.21 (DEVDD), U501.29 (DEVDD), U501.39 (DEVDD), U501.46 (EVDD)
/RF/RF09_N: L503.3, U501.9 (RFN09)
/RF/RF09_P: L503.4, U501.8 (RFP09)
/RF/RF24_N: C502.1, U501.5 (RFN24)
/RF/RF24_P: C503.1, U501.4 (RFP24)
GND: C501.2, C505.2, C506.2, C508.2, C511.2, C512.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, D501.1 (A1), FL501.2 (GND), FL501.4 (GND), FL502.2 (GND), FL502.4 (GND), J501.2 (Ext), J504.1 (Shield), L502.2 (DC_Feed/RF_GND), L502.5 (GND), R501.2, SW501.5 (GND), U501.3 (AVSS), U501.6 (AVSS), U501.7 (AVSS), U501.10 (AVSS), U501.16 (AVSS), U501.19 (AVSS), U501.20 (DVSS), U501.23 (DVSS), U501.24 (DVSS), U501.32 (DVSS), U501.38 (DVSS), U501.45 (AVSS), U501.48 (AVSS), U501.49 (AVSS), X501.1 (GND), X501.2 (GND); also elsewhere on the board
unnamed: C505.1, L503.2
unnamed: C513.2, D501.2 (A2), J501.1 (In)
unnamed: FL501.1 (IN), L503.1
unnamed: C509.1, FL501.3 (OUT)
unnamed: FL502.1 (IN), L502.1 (IN)
unnamed: C510.1, FL502.3 (OUT)
unnamed: J502.1, U501.1 (FEA24)
unnamed: J502.2, U501.2 (FEB24)
unnamed: J503.1, U501.11 (FEA09)
unnamed: J503.2, U501.12 (FEB09)
unnamed: C502.2, L501.1, L502.3 (OUT1)
unnamed: C503.2, L501.2, L502.4 (OUT2)
unnamed: C513.1, SW501.2 (ANT)
unnamed: C509.2, SW501.4 (RF1)
unnamed: C510.2, SW501.6 (RF2)
unnamed: C514.1, U501.14 (AVDD0)
unnamed: C515.1, U501.47 (AVDD1)
unnamed: R503.2, U501.22 (CLKO)
unnamed: C508.1, U501.37 (DVDD)
unnamed: C504.2, C506.1, R501.1, U501.17 (TCXO)
unnamed 119: U501.18 (XTAL2); also elsewhere on the board
unnamed: C504.1, X501.3 (OUT)

Notes on the sheet:
DVSS and AVSS should be routed separately to the GND layer. Do not connect DVSS to exposed pad (see dev. board)

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

Notices in the files:
OpenHT-RF/OpenHT-RF.kicad_pcb:
Licensed under TAPR OHL
