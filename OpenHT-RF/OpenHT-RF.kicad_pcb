# Repository M17-Project/OpenHT-hw (continued)

## KiCad design OpenHT-RF/OpenHT-RF.kicad_pcb (continued)

Board: 4 copper layers, 60.0 x 127.0 mm, 197 parts (8 on the bottom side), 127 nets.

Other parts of the board:
C101: 1uF; C_0402_1005Metric
G1: KiCad-Logo2_5mm_SilkScreen
J301: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J302, J305: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J304: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
R101: 1kR; R_0402_1005Metric
R215, R504: 100R; R_0402_1005Metric
R502: 100kR; R_0402_1005Metric
SW101: 436351045816; SW_SPST_436351045816
WEEE01: WEEE-Logo_28.1x40mm_SilkScreen

Their connections:
/Connectors/FPGA_RST: J304.8; also elsewhere on the board
/Connectors/IO0: J305.8; also elsewhere on the board
/Connectors/IO1: J305.7; also elsewhere on the board
/Connectors/IO2: J305.1; also elsewhere on the board
/Connectors/IO3: J304.10; also elsewhere on the board
/Connectors/PTT: C101.1, J301.5, R101.2
/FPGA/TDO/SSO: R504.2; also elsewhere on the board
GND: C101.2, J302.6, J302.7, J304.4, R502.1, SW101.1; also elsewhere on the board
unnamed 55: J302.5; also elsewhere on the board
unnamed 62: J301.2; also elsewhere on the board
unnamed 63: J301.3; also elsewhere on the board
unnamed 64: J301.4; also elsewhere on the board
unnamed 65: J301.6; also elsewhere on the board
unnamed 66: J302.3; also elsewhere on the board
unnamed 71: J304.5; also elsewhere on the board
unnamed 72: J304.6; also elsewhere on the board
unnamed 73: J304.7; also elsewhere on the board
unnamed 74: J304.9; also elsewhere on the board
unnamed 75: J305.3; also elsewhere on the board
unnamed 76: J305.4; also elsewhere on the board
unnamed 77: J305.5; also elsewhere on the board
unnamed: R101.1, SW101.2
unnamed 119: R502.2; also elsewhere on the board

## Commit log

2023-02-12 Added TAPR Licence
2023-02-12 Created KiCad project for RF board
2023-02-15 project file upgraded to kicad v7.0
2023-02-17 lfcn-490 filter added
2023-02-18 pdf fix
    frame was missing
2023-02-19 Removed gitignore
    There is a gitignore file in the kicad project already
2023-02-19 Added description of Arduino connectors
2023-02-19 Added FPGA power rails
2023-02-20 FPGA diagram [WIP]
2023-02-21 Added FPGA documentation
2023-02-21 Updated FPGA, RF and connectors sheets [WIP]
2023-02-22 Updated pdf schematic
2023-02-22 Added M17 Kicad library
2023-02-22 Updated M17_kicad_library
2023-02-22 Updated FPGA schematic to use M17_kicad_library
2023-02-23 Updated RF schematic
2023-02-23 Removed old libs
2023-02-25 Updated power supply schematic
2023-02-26 Added RF baluns
2023-02-27 Added pushbutton controller for main power
2023-02-28 Updated FPGA power supply
    Design updated according to Lattice Hardware Checklist (https://www.latticesemi.com/view_document?document_id=52782)
2023-02-28 Fixed FPGA power supply
    vccio_1V8 is now correctly connected to 1V8
2023-03-05 [WIP]Updating power suply diagram
    Changing buck converter IC
2023-03-07 [WIP] Power supply diagram
2023-03-08 Finished power supply design
2023-03-08 Optimised IO routing, renumbered components
2023-03-08 Updated net classes
2023-03-09 Swapped AP7330 with AP7330D
2023-03-09 Added MPN for ferrite beads
2023-03-09 Updated PTT debounce circuit
2023-03-09 Updated RF schematic
    Added low-pass filter at CLKO, updated capacitor values to AVDD and VDD according to dev. board files
2023-03-09 Computed voltage margins on the power rails
    This allows to deduce the maximum ferrite beads DCR
2023-03-09 Updated power routing, added test points
2023-03-09 Added M17 logo
2023-03-09 [WIP] symbol-footprint association
2023-03-12 Added testpoint
2023-03-12 Fixed CLKOUT low pass filter
2023-03-12 Fixed BST capacitor placement
2023-03-12 Added mechanical holes
2023-03-12 Selected footprint
2023-03-13 Updated gitignore
2023-03-13 Imported components on PCB
2023-03-13 Updated switches
2023-03-13 Fixed 3.3V power symbol
    Use 3V3 everywhere instead of 3.3
2023-03-13 Updated QFN footprints
2023-03-13 Layout [WIP]
2023-03-14 Swapped LVDS pairs order
2023-03-14 Renamed RF differential signals
2023-03-14 Added missing decoupling capacitors
2023-03-14 Updated controlled impedance dimensions
2023-03-14 Connectors adjustments
2023-03-14 Speaker MPN
2023-03-14 [WIP] Layout
    Connectors are now correctly placed for the Nucleo Board
2023-03-14 Added documentation for XCVR and MCU
2023-03-15 Updated speaker footprint
    Using SMD footprint
2023-03-15 Updated default via parameters
2023-03-15 Rearanged IOs
2023-03-15 [WIP] Layout
    Routed FPGA IOs and LVDS pairs
2023-03-16 [WIP] Layout
    Flipped the content upside down for the SMA connector. Reorganized GPIOs. RF routing started.
2023-03-17 Delete PowerSupply.drawio
    empty file removal
2023-03-26 Updated SMA connector
2023-03-26 Added a load switch for the nucleo board
2023-03-26 Added battery measurement pin
2023-03-26 Updated comment
2023-03-31 Various schematic updates
    Edited IO names, updated load switch symbol, swapped RF switch inputs
2023-03-31 Updated PCB layout + step file
    PTT and power button now in their final location
2023-04-03 Updated push button footprint
    Now includes 3D model
2023-04-03 Power rails routing
2023-04-07 Routed FPGA power supply tracks
2023-04-12 Added power supply decoupling capacitor
2023-04-12 Power supply routing
    Finished routing power to the transceiver
2023-04-16 Various updates
    Updated some nets to ease up routing
    Updated testpoints to smaller size
    Added DNP capacitor next to RF switch
2023-04-16 [WIP] PCB Routing
    Routed most of the board.
2023-04-23 Modified 1V0 TP
2023-04-23 [WIP] PCB Routing
2023-04-23 Updated artifacts
2023-04-27 Updated Power supply
2023-04-28 Layout improvements and current measurement jumpers
2023-05-02 Layout improvements and reverse polarity protection
2023-05-03 Added DC-DC shield
2023-05-09 Updated M17_kicad_library links
2023-05-09 BOM updates
2023-05-09 Added shields
2023-05-09 Added TVS diode
2023-05-09 Changed battery connector
2023-05-09 Updated incorrect capacitor footprint
2023-05-09 [WIP] board layout
2023-05-10 Added OSHW logo, gnd TP and via stitching
    Also added comments, revision number, and an easter egg
2023-05-11 Labels and logos
2023-05-11 Added missing MPN
2023-05-11 Added NO AMBE logo
2023-05-11 Silkscreen layout and logos
2023-05-12 Added Leo Hofer's Callsign
2023-05-12 Fixed ERC errors
2023-05-12 Fixed DRC
2023-05-13 Fixed location of L502 silkscreen label
2023-05-14 Added polyfuse MPN to PCB
2023-05-14 Modified shields to use two symbols
    Allows to have the MPN of the lid in the schematic alongside the frame
2023-05-14 Added BOM generation script
2023-05-14 Completed components values
    Completed dielectric, rated voltage, tolerance, MPN
2023-05-14 Added complete bom file
2023-05-15 Fixed incorrect value for R502
2023-05-15 Exclude fiducials from bom
2023-05-15 Added MPN for L501
2023-05-15 Added MPN for speaker
2023-05-15 Added MPN for SMD jumpers
2023-05-15 Fixed tolerance for R214
2023-05-15 Set 100nF to 0.1uF
2023-05-15 Added MPN for generic components
2023-05-15 Various minor pcb updated
2023-05-15 Updated BOM and pdf schematic
2023-05-16 Fixed incorrect MPN for 4.7uF capacitors
2023-05-16 Modified netclasses and controlled impedance tracks
2023-05-16 Fixed differential pairs and RF related DRC errors
2023-05-19 Updated stackup
2023-12-07 Misc. updates
2023-12-07 Updated mounting holes
    Adresses #5
2023-12-07 Removed C507
    Addresses #4
2023-12-07 Update M17_kicad_library
2023-12-07 Updated M17 logo
    Updated to keep it consistent with M17_kicad_library
2023-12-07 Fixed TPS22810DBV pinout
    Addresses #1
2023-12-07 Fixed DRC issues
