File: OpenHT-RF/pwr.kicad_sch (KiCad schematic)
At the start: 54 parts, among them J201 Conn_01x02, SW201 436351045816, U201 LTC2954-1, U202 TPS65261RHBx, U203 AP7330-W5-7

Commit message: Added a load switch for the nucleo board
Parts:
- added C226: 6.8nF, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- added R301: 100R, Resistor_SMD:R_0402_1005Metric, symbol Device:R
- added U204: TPS22810DBVR, Package_TO_SOT_SMD:SOT-23-6, symbol Power_Management:TPS22810DRV
Connections:
- net +BATT: now also U204.6 (VIN)
- net GND: now also C226.2, U204.4 (GND), U204.7 (GND)
- net PWR_EN: now also U204.5 (EN/UVLO)
- new net: R301.1, U204.2 (QOD)
- new net: C226.1, U204.3 (CT)
- new net VDD: R301.2, U204.1 (VOUT)
Other:
- moved on the sheet: C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217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

Commit message: Various schematic updates
Edited IO names, updated load switch symbol, swapped RF switch inputs
Parts:
- added C227: 100nF, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- U204: symbol Power_Management:TPS22810DRV -> M17_power:TPS22810DRV
Connections:
- net +BATT: now also C227.1
- net GND: now also C227.2; no longer U204.7 (GND)
Changed lines of the file:
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@@
   (junction (at 270.51 91.44) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 82.55 167.64) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 259.08 91.44) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 82.55 177.8) (xy 82.55 180.34))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 82.55 100.33) (xy 82.55 107.95))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 82.55 167.64) (xy 95.25 167.64))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 214.63 69.85) (xy 214.63 71.12))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 88.9 167.64) (xy 95.25 167.64))
+  (wire (pts (xy 76.2 167.64) (xy 82.55 167.64))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 82.55 167.64) (xy 82.55 170.18))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 270.51 39.37) (xy 270.51 41.91))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 88.9 165.1) (xy 88.9 167.64))
+  (wire (pts (xy 76.2 166.37) (xy 76.2 167.64))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (symbol (lib_id "power:+BATT") (at 88.9 165.1 0) (unit 1)
+  (symbol (lib_id "power:+BATT") (at 76.2 166.37 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR0239" (at 88.9 168.91 0)
+    (property "Reference" "#PWR0239" (at 76.2 170.18 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "+BATT" (at 88.9 161.29 0)
+    (property "Value" "+BATT" (at 76.2 162.56 0)
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 88.9 165.1 0)
+    (property "Footprint" "" (at 76.2 166.37 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 88.9 165.1 0)
+    (property "Datasheet" "" (at 76.2 166.37 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 82.55 180.34 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR0248" (at 82.55 186.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 82.55 185.42 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 82.55 180.34 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 82.55 180.34 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "OpenHT-RF"
+        (path "/3c300b59-23ec-47f8-bb91-29ca34130bcf/17571ff2-f5b8-49d7-92c6-d2c188350dd2"
+          (reference "#PWR0248") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 260.35 157.48 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "Device:C") (at 82.55 173.99 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C227" (at 78.74 173.355 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "100nF" (at 78.74 175.895 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 81.5848 177.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 82.55 173.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "OpenHT-RF"
+        (path "/3c300b59-23ec-47f8-bb91-29ca34130bcf/17571ff2-f5b8-49d7-92c6-d2c188350dd2"
+          (reference "C227") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:VDD") (at 127 166.37 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "Power_Management:TPS22810DRV") (at 105.41 170.18 0) (unit 1)
+  (symbol (lib_id "M17_power:TPS22810DRV") (at 105.41 170.18 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
     (property "Reference" "U204" (at 105.41 161.29 0)
@@
     (pin "5")
     (pin "6")
-    (pin "7")
     (instances
       (project "OpenHT-RF"

Commit message: Various updates
Updated some nets to ease up routing
Updated testpoints to smaller size
Added DNP capacitor next to RF switch
Parts:
- TP201, TP202, TP203, TP204, TP205, TP206: footprint TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm -> Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm" (at 34.29 64.77 0)
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 64.77 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm" (at 34.29 72.39 0)
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm" (at 34.29 74.93 0)
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm" (at 34.29 69.85 0)
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 69.85 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm" (at 34.29 67.31 0)
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 67.31 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.50mm_Drill1.0mm" (at 34.29 62.23 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 62.23 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
