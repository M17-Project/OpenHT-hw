File: OpenHT-RF/pwr.kicad_sch (KiCad schematic)
At the start: 58 parts, among them J201 Conn_01x02, SW201 436351045816, U201 LTC2954-1, U202 TPS65261RHBx, U203 AP7330-W5-7, U204 TPS22810DBVR

Commit message: Modified 1V0 TP
Parts:
- removed TP204: TestPoint, Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork, symbol Connector:TestPoint
Other:
- moved on the sheet: TP205, TP206
Changed lines of the file:
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@@
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 34.29 74.93) (xy 44.45 74.93))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 34.29 77.47) (xy 43.18 77.47))
+  (wire (pts (xy 34.29 74.93) (xy 43.18 74.93))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 35.56 80.01) (xy 35.56 81.28))
+  (wire (pts (xy 35.56 77.47) (xy 35.56 78.74))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 34.29 80.01) (xy 35.56 80.01))
+  (wire (pts (xy 34.29 77.47) (xy 35.56 77.47))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "PWR_EN" (at 43.18 77.47 180) (fields_autoplaced)
+  (label "PWR_EN" (at 43.18 74.93 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     )
   )
-  (symbol (lib_id "Connector:TestPoint") (at 34.29 77.47 90) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "TP205" (at 29.21 77.47 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "TestPoint" (at 30.988 74.93 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 72.39 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 34.29 72.39 0)
+  (symbol (lib_id "Connector:TestPoint") (at 34.29 74.93 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "TP205" (at 29.21 74.93 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "TestPoint" (at 30.988 72.39 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 34.29 69.85 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Connector:TestPoint") (at 34.29 80.01 90) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "TP206" (at 29.21 80.01 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "TestPoint" (at 30.988 77.47 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 34.29 74.93 0)
+  (symbol (lib_id "Connector:TestPoint") (at 34.29 77.47 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "TP206" (at 29.21 77.47 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "TestPoint" (at 30.988 74.93 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 34.29 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         (path "/3c300b59-23ec-47f8-bb91-29ca34130bcf/17571ff2-f5b8-49d7-92c6-d2c188350dd2"
           (reference "R209") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "Connector:TestPoint") (at 34.29 74.93 90) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "TP204" (at 29.21 74.93 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "TestPoint" (at 30.988 72.39 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Footprint" "Connector_Pin:Pin_D0.7mm_L6.5mm_W1.8mm_FlatFork" (at 34.29 69.85 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 34.29 69.85 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "OpenHT-RF"
-        (path "/3c300b59-23ec-47f8-bb91-29ca34130bcf/17571ff2-f5b8-49d7-92c6-d2c188350dd2"
-          (reference "TP204") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "power:+1V0") (at 44.45 74.93 270) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR0208" (at 40.64 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+1V0" (at 48.26 75.565 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 44.45 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 44.45 74.93 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "OpenHT-RF"
-        (path "/3c300b59-23ec-47f8-bb91-29ca34130bcf/17571ff2-f5b8-49d7-92c6-d2c188350dd2"
-          (reference "#PWR0208") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 35.56 81.28 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR0204" (at 35.56 87.63 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 35.56 86.36 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 35.56 81.28 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 35.56 81.28 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "power:GND") (at 35.56 78.74 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR0204" (at 35.56 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 35.56 83.82 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 35.56 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 35.56 78.74 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Updated Power supply
Parts:
- added C228, C229: 470pF, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- L201: MPN NRS5030T330MMGJ -> LSXND5050XKT330MMG
- L202: footprint Inductor_SMD:L_Taiyo-Yuden_NR-50xx -> M17_misc_passive:L_Wurth_WE-LQSF-4828; MPN NRS5030T470MMGJ -> 74406043470
- R207: value 8.66kR -> 1.6kR
Connections:
- net +1V8: now also C229.1
- net +3V3: now also C228.1
- net at R209.2, R210.1, U202.22 (FB1): now also C228.2
- net at R211.2, R212.1, U202.6 (FB2): now also C229.2
Other:
- moved on the sheet: C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217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

Commit message: Layout improvements and current measurement jumpers
Parts:
- added J202: MS338-10F, symbol Device:RFShield_TwoPieces
- added JP202, JP203, JP204: Jumper_2_Bridged, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Right, symbol Jumper:Jumper_2_Bridged
- JP201: footprint Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Right
Connections:
- net +1V0: now also JP204.2 (B); no longer C225.1, R213.1, U203.5 (V_{out})
- net +1V8: now also JP203.2 (B); no longer C219.1, C222.1, C224.1, C229.1, L202.2, R211.1
- net +3V3: now also JP202.2 (B); no longer C218.1, C221.1, C223.1, C228.1, L201.2, R209.1
- net GND: now also J202.1 (Shield)
- new net: C219.1, C222.1, C224.1, C229.1, JP203.1 (A), L202.2, R211.1
- new net: C218.1, C221.1, C223.1, C228.1, JP202.1 (A), L201.2, R209.1
- new net: C225.1, JP204.1 (A), R213.1, U203.5 (V_{out})
Other:
- moved on the sheet: C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217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

Commit message: Layout improvements and reverse polarity protection
Parts:
- added Q201: DMP3099L-7, Package_TO_SOT_SMD:SOT-23, symbol Device:Q_PMOS_GSD
Connections:
- net +BATT: now also Q201.2 (S); no longer F201.2
- net GND: now also Q201.1 (G)
- new net: F201.2, Q201.3 (D)
Other:
- moved on the sheet: C203, C204, F201, J201, R202, SW201, U201
